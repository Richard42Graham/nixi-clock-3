#include <stdio.h>
#include <stdlib.h>
#include <errno.h>
#include <string.h>
#include <wiringPi.h>
#include <time.h>
#include <sys/time.h>
#include <math.h>
#include <unistd.h>
#include <string.h>

const int iOchip = 0x20;

typedef struct digit digit;

struct digit {
   char chip;
   char adress;
};

//			       0             1           2	       3	      4		    5	         6	     7		  8	       9	  .L		.R
digit tubes[7][12] = {
			{ {0x40, 0x0d},{0x40, 0x15},{0x40, 0x19},{ 0x40, 0x1d},{ 0x40, 0x21},{ 0x40, 0x25},{ 0x40, 0x29},{0x40, 0x2d},{0x40, 0x31},{0x40, 0x35},{0x40,0x11},{0x40,0x09}},	// H _:_ _ : _ _ : _
			{ {0x41, 0x21},{0x41, 0x2D},{0x40, 0x45},{ 0x40, 0x41},{ 0x40, 0x30},{ 0x40, 0x39},{ 0x41, 0x11},{0x41, 0x15},{0x41, 0x19},{0x41, 0x1d},{0x41,0x29},{0x41,0x25}},	// _ H : _ _ : _ _ : _
                        { {0x41, 0x41},{0x41, 0x39},{0x41, 0x35},{ 0x41, 0x31},{ 0x41, 0x09},{ 0x41, 0x0d},{ 0x42, 0x35},{0x42, 0x41},{0x42, 0x2d},{0x42, 0x29},{0x41,0x3d},{0x41,0x45}},       // _ _ : M _ : _ _ : _
                        { {0x42, 0x0d},{0x42, 0x21},{0x42, 0x1d},{ 0x42, 0x19},{ 0x42, 0x15},{ 0x42, 0x11},{ 0x42, 0x39},{0x42, 0x3d},{0x42, 0x41},{0x42, 0x45},{0x42,0x25},{0x42,0x0d}},        // _ _ : _ M : _ _ : _
                        { {0x00, 0x00},{0x43, 0x29},{0x43, 0x11},{ 0x43, 0x25},{ 0x43, 0x1d},{ 0x43, 0x19},{ 0x43, 0x15},{0x43, 0x09},{0x43, 0x35},{0x43, 0x31},{0x43,0x21},{0x43,0x0d}},        // _ _ : _ _ : S _ : _
                        { {0x43, 0x41},{0x43, 0x3D},{0x44, 0x11},{ 0x44, 0x25},{ 0x44, 0x1d},{ 0x44, 0x19},{ 0x44, 0x15},{0x43, 0x39},{0x44, 0x29},{0x43, 0x45},{0x44,0x21},{0x44,0x0d}},        // _ _ : _ _ : _ S : _
                        { {0x45, 0x3d},{0x45, 0x35},{0x45, 0x0d},{ 0x45, 0x21},{ 0x45, 0x19},{ 0x45, 0x15},{ 0x45, 0x11},{0x45, 0x39},{0x45, 0x45},{0x45, 0x41},{0x45,0x1d},{0x45,0x09}}        // _ _ : _ _ : _ _ : D



};

int main(int argc, char** arg){
int x,i,y;
wiringPiI2CWriteReg8(iOchip,0x00,0x00);         // set port A on IO chip as all outputs
wiringPiI2CWriteReg8(iOchip,0x01,0x00);         // set port B on IO chip as all outputs

// if input value !0 HV on
//if(*arg == (char))
//{
wiringPiI2CWriteReg8(iOchip,14,00);	// turn on HV power suply

// else
//	{
//		wiringPiI2CWriteReg8(IOchip,14,00);	// turn of HV power suply
//	}
//}

 for (i=0; i=6; i++)
{
	 for (y=0; y=12; y++)
		{
		 for (x=0; x=10; x++)				// count up fading digits
			{
			wiringPiI2CWriteReg8( tubes[i,y], x);	// set tube and value
			// delay
			}

                 for (x=10; x=0; x--)				// count down fading digit
                        {
                        wiringPiI2CWriteReg8( tubes[i,y], x);   // set tube and value
			// delay
                        }
		}
}




}
